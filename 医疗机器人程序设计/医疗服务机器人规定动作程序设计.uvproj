# Keil uVision project 医疗服务机器人规定动作程序设计.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 医疗服务机器人规定动作程序设计 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: MedicalService.c
